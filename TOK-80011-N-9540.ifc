Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-03-24T09:15:44
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: Tokyo 2 Luminaires for track
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: Tokyo 2 Luminaires for track; Light output ratio: 1; Luminous flux: 448 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 448 lm; LightEmitterNominalPower: 7 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorRenderingIndex: 95

# IfcFlowTerminal: Tokyo 2 luminaires for track
In: Default Building
Type - Description: - Lamp MR16-GU10 - CRI Ra > 95 - Colour Temperature 3000K , 4000K - Die-cast aluminium housing with powder coating - Adjustable: Tilt 90°, Rotation 350° - PAR16 GU10 socket, LED and halogen lamps are suitable (up to 30W) - With 3-phase universal adapter - Anti-glare ring in black, optional in gold; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Tokyo, Luminaires for track; Housing color: White, Black, Silver
General Information - Article number: TOK-80011-N-9540; Article name: Tokyo 2 luminaires for track; Weight: 0.45 kg; Case height: 13.5 cm; Case diameter: 6 cm; Uld creation date: 24.03.2020 08:15:44
Mounting Information - Recessed depth: 0.1 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 7.5 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 7.5 W; LightFixtureMountingType: SurfaceMounted; LightFixturePlacingType: Ceiling; ManufacturersSpecificInformation: LIGMAN
